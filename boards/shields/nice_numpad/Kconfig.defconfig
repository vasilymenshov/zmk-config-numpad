## boards/shields/nice_numpad/Kconfig.defconfig
```kconfig
if SHIELD_NICE_NUMPAD

config ZMK_KEYBOARD_NAME
    default "Nice Numpad"

endif
```
